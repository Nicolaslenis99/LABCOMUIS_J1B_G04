options:
  parameters:
    author: Omar galvis y nicolas lenis
    copyright: uis
    generate_options: qt_gui
    id: caracterizacion
    output_language: python
    title: caracterizacion
  states: {}

blocks:
- name: fr
  id: variable_qtgui_range
  parameters:
    label: Frecuencia señal cuadrada
    start: '0'
    step: '1'
    stop: '100000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fr
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 50-w
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: practica5_3
  id: practica5
  parameters:
    d: w
    fs: fr
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', practica5_3, '0']
- [analog_sig_source_x_0_0, '0', blocks_delay_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_xx_1, '0', qtgui_time_sink_x_0, '1']
- [practica5_3, '0', blocks_add_xx_0, '0']
- [practica5_3, '0', qtgui_freq_sink_x_0, '0']
- [practica5_3, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
