options:
  parameters:
    author: omar galvis y nicolas lenis
    generate_options: qt_gui
    id: practica4_2
    output_language: python
    title: modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del Tx
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '0'
    step: '1'
    stop: '100000'
    value: '50'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '0'
    step: '1'
    stop: '10000'
    value: '50'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: coeficiente kp
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: practica4_0
  id: practica4
  parameters:
    Ac: '0.1'
    Kp: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', practica4_0, '0']
- [practica4_0, '0', qtgui_freq_sink_x_0, '0']
- [practica4_0, '0', qtgui_time_sink_x_0, '0']
- [practica4_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
